# IAR project bmdware.ewp, settings and files
configuration release_nrf52 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NRF52; S132; BLE_STACK_SUPPORT_REQD; CONFIG_NFCT_PINS_AS_GPIOS; APP_START_ADDRESS=0x1F000; NRF_SD_BLE_API_VERSION=3; SDK_VERSION=12
  ICCARM.CCIncludePath2: ..; ../../../common; ../../../common/at; ../../../common/ble; ../../../common/lib; ../../../common/timeslot; ../../../nrf5_sdk/components/ble/ble_debug_assert_handler; ../../../nrf5_sdk/components/ble/ble_error_log; ../../../nrf5_sdk/components/ble/ble_dtm; ../../../nrf5_sdk/components/ble/ble_services/ble_dis; ../../../nrf5_sdk/components/ble/common; ../../../nrf5_sdk/components/drivers_nrf/ble_flash; ../../../nrf5_sdk/components/drivers_nrf/common; ../../../nrf5_sdk/components/drivers_nrf/delay; ../../../nrf5_sdk/components/drivers_nrf/fstorage; ../../../nrf5_sdk/components/drivers_nrf/hal; ../../../nrf5_sdk/components/libraries/ic_info; ../../../nrf5_sdk/components/libraries/timer; ../../../nrf5_sdk/components/libraries/util; ../../../nrf5_sdk/components/softdevice/common/softdevice_handler; ../../../nrf5_sdk/components/softdevice/s132/headers; ../../../nrf5_sdk/components/softdevice/s132/headers/nrf52; ../../../nrf5_sdk/components/drivers_nrf/config; ../../../nrf5_sdk/components/drivers_nrf/clock; ../../../nrf5_sdk/components/libraries/fstorage; ../../../nrf5_sdk/components/libraries/experimental_section_vars; ../../../nrf5_sdk/external/segger_rtt; ../../../nrf5_sdk/components/libraries/log; ../../../nrf5_sdk/components/libraries/log/src; ../../../nrf5_sdk/components/device; ../../../nrf5_sdk/components/toolchain; ../../../nrf5_sdk/components/drivers_nrf/spi_slave
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ../../n52sdk/components/ble/common; ../../n52sdk/components/ble/ble_dtm; ../../n52sdk/components/ble/ble_debug_assert_handler; ../../n52sdk/components/ble/ble_services/ble_dis; ../../n52sdk/components/libraries/gpiote; ../../n52sdk/components/libraries/timer; ../../n52sdk/components/libraries/util; ../../n52sdk/bsp; ../../n52sdk/components/softdevice/common/softdevice_handler; ../../n52sdk/components/drivers_nrf/ble_flash; ../../n52sdk/components/drivers_nrf/delay; ../../n52sdk/components/drivers_nrf/pstorage; ../../n52sdk/components/drivers_nrf/pstorage/config; ../../n52sdk/components/device; ../../n52sdk/components/softdevice/s132/headers; ../../n52sdk/components/softdevice/s132/headers/nrf52; ../../n52sdk/components/drivers_nrf/hal; ../../n52sdk/components/ble/ble_error_log
  OBJCOPY.OOCOutputFile: bmdware.srec
  ILINK.IlinkOutputFile: template_project.out
configuration debug_nrf52 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NRF52; S132; BLE_STACK_SUPPORT_REQD; CONFIG_NFCT_PINS_AS_GPIOS; APP_START_ADDRESS=0x1F000; NRF_SD_BLE_API_VERSION=3; SDK_VERSION=12; DEBUG_NRF_USER; DEBUG; BMD_DEBUG
  ICCARM.CCIncludePath2: ..; ../../../common; ../../../common/at; ../../../common/ble; ../../../common/lib; ../../../common/timeslot; ../../../nrf5_sdk/components/ble/ble_debug_assert_handler; ../../../nrf5_sdk/components/ble/ble_error_log; ../../../nrf5_sdk/components/ble/ble_dtm; ../../../nrf5_sdk/components/ble/ble_services/ble_dis; ../../../nrf5_sdk/components/ble/common; ../../../nrf5_sdk/components/drivers_nrf/ble_flash; ../../../nrf5_sdk/components/drivers_nrf/common; ../../../nrf5_sdk/components/drivers_nrf/delay; ../../../nrf5_sdk/components/drivers_nrf/fstorage; ../../../nrf5_sdk/components/drivers_nrf/hal; ../../../nrf5_sdk/components/libraries/ic_info; ../../../nrf5_sdk/components/libraries/timer; ../../../nrf5_sdk/components/libraries/util; ../../../nrf5_sdk/components/softdevice/common/softdevice_handler; ../../../nrf5_sdk/components/softdevice/s132/headers; ../../../nrf5_sdk/components/softdevice/s132/headers/nrf52; ../../../nrf5_sdk/components/drivers_nrf/config; ../../../nrf5_sdk/components/libraries/log/src; ../../../nrf5_sdk/components/libraries/log; ../../../nrf5_sdk/components/drivers_nrf/clock; ../../../nrf5_sdk/components/libraries/fstorage; ../../../nrf5_sdk/components/libraries/experimental_section_vars; ../../../nrf5_sdk/external/segger_rtt
configuration release_nrf51 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NRF51; S130; SDK11; DEBUG_NRF_USER; BLE_STACK_SUPPORT_REQD; BMDWARE_INCLUDE_UART; CONFIG_NFCT_PINS_AS_GPIOS; APP_START_ADDRESS=0x1B000
  ICCARM.CCIncludePath2: ..; ../../../common; ../../../common/at; ../../../common/ble; ../../../common/lib; ../../../common/timeslot; ../../../nrf5_sdk/components/ble/ble_debug_assert_handler; ../../../nrf5_sdk/components/ble/ble_error_log; ../../../nrf5_sdk/components/ble/ble_dtm; ../../../nrf5_sdk/components/ble/ble_services/ble_dis; ../../../nrf5_sdk/components/ble/common; ../../../nrf5_sdk/components/drivers_nrf/ble_flash; ../../../nrf5_sdk/components/drivers_nrf/common; ../../../nrf5_sdk/components/drivers_nrf/delay; ../../../nrf5_sdk/components/drivers_nrf/pstorage; ../../../nrf5_sdk/components/drivers_nrf/hal; ../../../nrf5_sdk/components/libraries/ic_info; ../../../nrf5_sdk/components/libraries/timer; ../../../nrf5_sdk/components/libraries/util; ../../../nrf5_sdk/components/softdevice/common/softdevice_handler; ../../../nrf5_sdk/components/drivers_nrf/config; ../../../nrf5_sdk/components/softdevice/s130/headers; ../../../nrf5_sdk/components/softdevice/s130/headers/nrf51
configuration debug_nrf51 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  group (top)
    ../../../nrf5_sdk/components/drivers_nrf/spi_slave/: nrf_drv_spis.c nrf_drv_spis.h nrf_drv_spis_dox_config.h
  group common
    ../../../common/: bootloader_info.c crc.c gpio_ctrl.c lock.c rig_firmware_info.c rigdfu.c rigdfu_util.c ringbuf.c service.c settings.c sys_init.c timer.c uart.c
  group common/at
    ../../../common/at/: at_commands.c at_commands.h at_commands_beacon.c at_commands_gpio.c at_commands_misc.c at_commands_uart.c at_proc.c at_utils.c
  group common/ble
    ../../../common/ble/: advertising.c ble_beacon_config.c ble_dtm.c ble_nus.c gap.c gatt.c
  group common/lib
    ../../../common/lib/: simple_uart.c simple_uarte.c sw_irq_manager.c
  group common/timeslot
    ../../../common/timeslot/: nrf_advertiser.c ts_controller.c ts_peripheral.c ts_rng.c
  group nordic/ble
    ../../../nrf5_sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../nrf5_sdk/components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../../../nrf5_sdk/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../nrf5_sdk/components/ble/ble_error_log/: ble_error_log.c
  group nordic/device
    ../../../nrf5_sdk/components/toolchain/arm/: arm_startup_nrf52.s
    ../../../nrf5_sdk/components/toolchain/: system_nrf52.c
  group nordic/drivers
    ../../../nrf5_sdk/components/drivers_nrf/ble_flash/: ble_flash.c
    ../../../nrf5_sdk/components/drivers_nrf/common/: nrf_drv_common.c
  group nordic/libraries
    ../../../nrf5_sdk/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../nrf5_sdk/components/libraries/timer/: app_timer.c
    ../../../nrf5_sdk/components/libraries/fstorage/: fstorage.c
  group nordic/softdevice
    ../../../nrf5_sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group RTT
    ../../../nrf5_sdk/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group source
    ../../../nrf5_sdk/components/device/: compiler_abstraction.h nrf.h
    ../: gpio_ctrl_def.c main.c sdk_config.h storage_intf.c version.h
  group test
    ../: bmd200_dtm.c bmd200_selftest.c bmd_dtm.c bmd_selftest.c
