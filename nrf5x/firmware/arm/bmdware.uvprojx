# Keil uVision project bmdware.uvprojx, settings and files
target release_nrf52 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bmdware_rel_nrf52_s132 +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52 S132 BLE_STACK_SUPPORT_REQD CONFIG_NFCT_PINS_AS_GPIOS APP_START_ADDRESS=0x1F000 NRF_SD_BLE_API_VERSION=3 SDK_VERSION=12
  c include: ..;..\..\..\common;..\..\..\common\at;..\..\..\common\ble;..\..\..\common\lib;..\..\..\common\timeslot;..\..\..\nrf5_sdk\components\ble\ble_debug_assert_handler;..\..\..\nrf5_sdk\components\ble\ble_error_log;..\..\..\nrf5_sdk\components\ble\ble_dtm;..\..\..\nrf5_sdk\components\ble\ble_services\ble_dis;..\..\..\nrf5_sdk\components\ble\common;..\..\..\nrf5_sdk\components\drivers_nrf\ble_flash;..\..\..\nrf5_sdk\components\drivers_nrf\common;..\..\..\nrf5_sdk\components\drivers_nrf\delay;..\..\..\nrf5_sdk\components\drivers_nrf\fstorage;..\..\..\nrf5_sdk\components\drivers_nrf\hal;..\..\..\nrf5_sdk\components\libraries\ic_info;..\..\..\nrf5_sdk\components\libraries\timer;..\..\..\nrf5_sdk\components\libraries\util;..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler;..\..\..\nrf5_sdk\components\softdevice\s132\headers;..\..\..\nrf5_sdk\components\softdevice\s132\headers\nrf52;..\..\..\nrf5_sdk\components\drivers_nrf\config;..\..\..\nrf5_sdk\components\drivers_nrf\clock;..\..\..\nrf5_sdk\components\libraries\fstorage;..\..\..\nrf5_sdk\components\libraries\experimental_section_vars;..\..\..\nrf5_sdk\external\segger_rtt;..\..\..\nrf5_sdk\components\libraries\log;..\..\..\nrf5_sdk\components\libraries\log\src
  asm include: ..;..\..\n52sdk\components\ble\common;..\..\n52sdk\components\ble\ble_dtm;..\..\n52sdk\components\ble\ble_debug_assert_handler;..\..\n52sdk\components\ble\ble_services\ble_dis;..\..\n52sdk\components\libraries\gpiote;..\..\n52sdk\components\libraries\timer;..\..\n52sdk\components\libraries\util;..\..\n52sdk\bsp;..\..\n52sdk\components\softdevice\common\softdevice_handler;..\..\n52sdk\components\drivers_nrf\ble_flash;..\..\n52sdk\components\drivers_nrf\delay;..\..\n52sdk\components\drivers_nrf\pstorage;..\..\n52sdk\components\drivers_nrf\pstorage\config;..\..\n52sdk\components\device;..\..\n52sdk\components\softdevice\s132\headers;..\..\n52sdk\components\softdevice\s132\headers\nrf52;..\..\n52sdk\components\drivers_nrf\hal;..\..\n52sdk\components\ble\ble_error_log
  memory RVCT4: ROM 0x1f000 size 0x28000
  memory RVCT9: RAM 0x20003800 size 0xc800
  group common
    ../../../common/: bootloader_info.c crc.c gpio_ctrl.c lock.c rig_firmware_info.c rigdfu.c rigdfu_util.c ringbuf.c service.c settings.c sys_init.c timer.c uart.c
  group common/at
    ../../../common/at/: at_commands.h at_commands.c at_commands_beacon.c at_commands_gpio.c at_commands_misc.c at_commands_uart.c at_proc.c at_utils.c
  group common/ble
    ../../../common/ble/: advertising.c ble_beacon_config.c ble_dtm.c ble_nus.c gap.c gatt.c
  group common/lib
    ../../../common/lib/: simple_uart.c simple_uarte.c sw_irq_manager.c
  group common/timeslot
    ../../../common/timeslot/: nrf_advertiser.c ts_controller.c ts_peripheral.c ts_rng.c
  group nordic/ble
    ../../../nrf5_sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../nrf5_sdk/components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../../../nrf5_sdk/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../nrf5_sdk/components/ble/ble_error_log/: ble_error_log.c
  group nordic/device
    ../../../nrf5_sdk/components/toolchain/arm/: arm_startup_nrf52.s
    ../../../nrf5_sdk/components/toolchain/: system_nrf52.c
  group nordic/drivers
    ../../../nrf5_sdk/components/drivers_nrf/ble_flash/: ble_flash.c
    ../../../nrf5_sdk/components/drivers_nrf/common/: nrf_drv_common.c
  group nordic/libraries
    ../../../nrf5_sdk/components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c app_util_platform.c
    ../../../nrf5_sdk/components/libraries/timer/: app_timer.c
    ../../../nrf5_sdk/components/libraries/fstorage/: fstorage.c
  group nordic/softdevice
    ../../../nrf5_sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group source
    ../: gpio_ctrl_def.c storage_intf.c version.h sdk_config.h
    ./../: main.c
  group test
    ../: bmd_dtm.c bmd_selftest.c bmd200_dtm.c bmd200_selftest.c
  group RTT
    ../../../nrf5_sdk/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
target debug_nrf52 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.0
  cpu: as above
  output: bmdware_dbg_nrf52_s132 +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52 S132 BLE_STACK_SUPPORT_REQD CONFIG_NFCT_PINS_AS_GPIOS APP_START_ADDRESS=0x1F000 NRF_SD_BLE_API_VERSION=3 SDK_VERSION=12 DEBUG_NRF_USER DEBUG BMD_DEBUG
  c include: ..;..\..\..\common;..\..\..\common\at;..\..\..\common\ble;..\..\..\common\lib;..\..\..\common\timeslot;..\..\..\nrf5_sdk\components\ble\ble_debug_assert_handler;..\..\..\nrf5_sdk\components\ble\ble_error_log;..\..\..\nrf5_sdk\components\ble\ble_dtm;..\..\..\nrf5_sdk\components\ble\ble_services\ble_dis;..\..\..\nrf5_sdk\components\ble\common;..\..\..\nrf5_sdk\components\drivers_nrf\ble_flash;..\..\..\nrf5_sdk\components\drivers_nrf\common;..\..\..\nrf5_sdk\components\drivers_nrf\delay;..\..\..\nrf5_sdk\components\drivers_nrf\fstorage;..\..\..\nrf5_sdk\components\drivers_nrf\hal;..\..\..\nrf5_sdk\components\libraries\ic_info;..\..\..\nrf5_sdk\components\libraries\timer;..\..\..\nrf5_sdk\components\libraries\util;..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler;..\..\..\nrf5_sdk\components\softdevice\s132\headers;..\..\..\nrf5_sdk\components\softdevice\s132\headers\nrf52;..\..\..\nrf5_sdk\components\drivers_nrf\config;..\..\..\nrf5_sdk\components\libraries\log\src;..\..\..\nrf5_sdk\components\libraries\log;..\..\..\nrf5_sdk\components\drivers_nrf\clock;..\..\..\nrf5_sdk\components\libraries\fstorage;..\..\..\nrf5_sdk\components\libraries\experimental_section_vars;..\..\..\nrf5_sdk\external\segger_rtt
  asm include: as above
  memory RVCT4: ROM 0x1f000 size 0x28000
  memory RVCT9: RAM 0x20003800 size 0xc800
target release_nrf51 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bmdware_rel_nrf51_s130 +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51 S130 SDK11 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BMDWARE_INCLUDE_UART CONFIG_NFCT_PINS_AS_GPIOS APP_START_ADDRESS=0x1B000
  c include: ..;..\..\..\common;..\..\..\common\at;..\..\..\common\ble;..\..\..\common\lib;..\..\..\common\timeslot;..\..\..\nrf5_sdk\components\ble\ble_debug_assert_handler;..\..\..\nrf5_sdk\components\ble\ble_error_log;..\..\..\nrf5_sdk\components\ble\ble_dtm;..\..\..\nrf5_sdk\components\ble\ble_services\ble_dis;..\..\..\nrf5_sdk\components\ble\common;..\..\..\nrf5_sdk\components\drivers_nrf\ble_flash;..\..\..\nrf5_sdk\components\drivers_nrf\common;..\..\..\nrf5_sdk\components\drivers_nrf\delay;..\..\..\nrf5_sdk\components\drivers_nrf\pstorage;..\..\..\nrf5_sdk\components\drivers_nrf\hal;..\..\..\nrf5_sdk\components\libraries\ic_info;..\..\..\nrf5_sdk\components\libraries\timer;..\..\..\nrf5_sdk\components\libraries\util;..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler;..\..\..\nrf5_sdk\components\drivers_nrf\config;..\..\..\nrf5_sdk\components\softdevice\s130\headers;..\..\..\nrf5_sdk\components\softdevice\s130\headers\nrf51
  asm include: as above
  memory RVCT4: ROM 0x1b000 size 0xf400
  memory RVCT9: RAM 0x20002800 size 0x5800
target debug_nrf51 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.0
  cpu: as above
  output: bmdware_debug_nrf51_s130 +hex
  AfterMake: ..\..\build-tools\make_binaries.bat $P @L $P..\
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: as above
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x1b000 size 0xf400
  memory RVCT9: RAM 0x20002800 size 0x5800
software components: CMSIS:CORE 5.0.0, Device:Startup 8.7.1
