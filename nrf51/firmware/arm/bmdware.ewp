# IAR project bmdware.ewp, settings and files
configuration BMDware-Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NRF51; SDK_OLD; RELEASE; BMD200; BLE_STACK_SUPPORT_REQD; APP_START_ADDRESS=0x18000
  ICCARM.CCIncludePath2: ..; ../../../common; ../../../common/at; ../../../common/ble; ../../../common/lib; ../../../common/timeslot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
configuration BMDware_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NRF51; BMD200; BMD_DEBUG; DEBUG_NRF_USER; BLE_STACK_SUPPORT_REQD; APP_START_ADDRESS=0x18000
  ICCARM.CCIncludePath2: ..
configuration BMDWare-Eval-Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NRF51; SDK_OLD; RELEASE; BLE_STACK_SUPPORT_REQD; BOARD_CUSTOM; BMD200_EVAL_V31; APP_START_ADDRESS=0x18000
configuration BMDware-Eval-Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NRF51; BMD_DEBUG; DEBUG_NRF_USER; BLE_STACK_SUPPORT_REQD; BOARD_PCA10001; BMDWARE_INCLUDE_UART; BMD200_EVAL_V31; APP_START_ADDRESS=0x18000
configuration BMDware-SCS001 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NRF51; DEBUG_NRF_USER; BLE_STACK_SUPPORT_REQD; BOARD_PCA10001; BMDWARE_INCLUDE_UART; BMDWARE_SCS_001
  ICCARM.CCIncludePath2: ..
configuration BMDware-Eval-Test-S120 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NRF51; DEBUG_NRF_USER; BLE_STACK_SUPPORT_REQD; BOARD_PCA10001; BMDWARE_INCLUDE_UART; BMD200_EVAL_V31; TEST_S120
  ICCARM.CCIncludePath2: ..
configuration BMDware-Eval-Test-S130 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NRF51; DEBUG_NRF_USER; BLE_STACK_SUPPORT_REQD; BOARD_PCA10001; BMDWARE_INCLUDE_UART; BMD200_EVAL_V31; TEST_S130
  ICCARM.CCIncludePath2: ..
  group common
    ../../../common/: bootloader_info.c crc.c gpio_ctrl.c lock.c rig_firmware_info.c rigdfu_util.c rigdfu.c ringbuf.c settings.c sys_init.c timer.c uart.c storage_intf.c
  group common/at
    ../../../common/at/: at_commands.h at_commands.c at_commands_beacon.c at_commands_gpio.c at_commands_misc.c at_commands_uart.c at_proc.c at_utils.c
  group common/ble
    ../../../common/ble/: advertising.c ble_beacon_config.c ble_nus.c gap.c
    ../../../common/: service.c
  group common/lib
    ../../../common/lib/: simple_uart.c
  group common/timeslot
    ../../../common/timeslot/: nrf_advertiser.c ts_controller.c ts_peripheral.c ts_rng.c
  group source
    ../: gpio_ctrl_def.c main.c pstorage_platform.h sw_irq_manager.c version.h
  group test
    ../: bmd200_dtm.c bmd200_selftest.c
